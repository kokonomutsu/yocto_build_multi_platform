# Add support for nanopc-t6 machine
COMPATIBLE_MACHINE:nanopc-t6 = "nanopc-t6"
