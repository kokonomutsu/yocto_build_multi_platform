# Add support for generic amlogic-s905x3 machine
# Use odroid-c4 model as it's compatible with S905X3

COMPATIBLE_MACHINE:amlogic-s905x3 = "amlogic-s905x3"
MODEL:amlogic-s905x3 = "odroid-c4"
